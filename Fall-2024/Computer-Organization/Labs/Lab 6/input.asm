.ORIG x4000
ST R1, INPUT_R1
ST R2, INPUT_R2
ST R3, INPUT_R3
ST R7, INPUT_R7


GETNUM

LD R1, ASCII_NEGATIVE
ADD R2, R2, #0
ADD R2, R2, #-10

GETC
OUT

ADD R0, R0, R1
ST R0, TENSPLACE

GETC
OUT

ADD R0, R0, R1
ST R0, ONESPLACE

AND R3, R3, #0

LD R0, TENSPLACE

GETDIGITS
    ADD R3, R3, R0
    ADD R2, R2, #1
    BRz ENDGETDIGITS
    BRnp GETDIGITS
ENDGETDIGITS

LD R0, ONESPLACE
ADD R3, R3, R0
ADD R0, R3, #0

LD R1, INPUT_R1
LD R2, INPUT_R2
LD R3, INPUT_R3
LD R7, INPUT_R7

RET


TENSPLACE .FILL #0
ONESPLACE .FILL #0
ASCII_NEGATIVE .FILL #-48
ASCII_POSITIVE .FILL #48
INPUT_R1 .FILL #0
INPUT_R2 .FILL #0
INPUT_R3 .FILL #0
INPUT_R7 .FILL #0
.END